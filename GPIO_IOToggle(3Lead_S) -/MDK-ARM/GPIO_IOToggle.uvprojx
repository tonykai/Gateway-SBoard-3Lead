# Keil uVision project GPIO_IOToggle.uvprojx, settings and files
target GPIO_IOToggle (ARM-ADS)
  device: STM32F401VETx STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(84000000) ELITTLE
  output: GPIO_IOToggle
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F401xx,
  c include: .\..\;.\..\..\..\..\Libraries\CMSIS\Include;.\..\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\..\..\..\..\Utilities\STM32F401-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group MDK-ARM
    ./../../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f401xx.s
  group STM32F401-Discovery
    ./../../../../Utilities/STM32F401-Discovery/: stm32f401_discovery.c
  group STM32F4xx_StdPeriph_Driver
    ./../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_spi.c diskio.c ff.c SPI_MSD0_Driver.c tm_stm32f4_usart.c stm32f4xx_adc.c stm32f4xx_tim.c tm_stm32f4_adc.c tm_stm32f4_gpio.c usb_bsp.c usb_core.c usb_dcd.c usb_dcd_int.c usbd_cdc_core.c usbd_cdc_vcp.c usbd_core.c usbd_desc.c usbd_ioreq.c usbd_req.c usbd_usr.c tm_stm32f4_usb_vcp.c stm32f4xx_i2c.c
  group User
    ./../: main.c stm32f4xx_it.c system_stm32f4xx.c
